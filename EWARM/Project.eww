<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\embedded_forth.ewp</path>
  </project>
  <batchBuild />
</workspace>
